Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-21T20:01:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Oct 21 20:01:39 2023 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\00bcdd55-e729-4a74-9953-da3241b926e8\9708e3f1-8ca3-4396-9343-8b4a0bcb4072\ifc * Database version: 5507 * Database creation date: Sat Oct 21 20:01:38 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Oct 21 20:01:38 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Oct 21 20:01:38 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 450822930037 Kitchen faucet, 1033(2023):450822930037 Kitchen faucet:388411
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 261.5 mm; FaucetNominalHeight: 338 mm; FaucetNominalWidth: 54 mm; HandShowerNominalDepth: 64.3 mm; HandShowerNominalHeight: 296.7 mm; HandShowerNominalWidth: 49.3 mm; InletConnectionSize: 10 mm
Type - General - Author: BIMStone; BIMObjectName: 450822930037(2020); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Washbasin faucet with high spout and Bidetta hand shower; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - EAN Number: 4057304014710; EN Standard: EN 817; ETIM Class Number: EC011431 Kitchen mixing tap; Noise Class: I (ISO 3822) Oras lab.; Sales Package dimensions (LxWxH): 362.0 x 278.0 x 63.0; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/450822930037; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL REACH: http://static.hansa.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/450822930037; Catalog Drawing URL: http://static.hansa.com/catdrw/450822930037; Dimension Drawing URL: http://static.hansa.com/dimdrw/450822930037; FDV Document URL: http://www.hansa.com/datasheet/450822930037/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/450822930037; Group: Kitchen faucet; Installation and Maintenance Guide URL: http://static.hansa.com/manual/450822930037; Manufacturer: HANSA; Market: International;Australia; Mobile Product Information URL: http://mpi.hansa.com/450822930037; Model: 450822930037 Kitchen faucet; Name_en: 450822930037 Kitchen faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 450822930037; Product Family: HANSAPINTO; Product Image URL: http://static.hansa.com/image/450822930037; Product URL: http://static.hansa.com/450822930037; Spare-Part Information URL: http://static.hansa.com/sp/450822930037; Technical DataSheet URL: http://www.hansa.com/datasheet/450822930037/en; Type Name: 450822930037 Kitchen faucet; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass;3S-installation system for safe and simple mounting; Aerator: Standard aerator; Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G1/2; Flow Rate At 300kPa: 0.0441433 m3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Spout Projection: 213 mm; Spout Swivel Range: 120° (80° / 40°); Spout Type: Swivel spout;Swivel range limiting option;Profile construction; Surface treatment: Chrome; Temperature: Temperature limiter; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1033(2023); Features: Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 450822930037; Name: 450822930037 Kitchen faucet; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:54x261.5x338 mm / Hand shower: 32x37x286 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 450822930037 Kitchen faucet; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 450822930037; Manufacturer: HANSA
Pset_ProductRequirements - Name: 450822930037 Kitchen faucet; Category: Plumbing Fixtures
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.158729 m2; Volume: 0.00571783 m3
Identity Data - Mark: 13
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1033(2023): 450822930037 Kitchen faucet; Family and Type: 1033(2023): 450822930037 Kitchen faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1033(2023): 450822930037 Kitchen faucet; Type Id: 1033(2023): 450822930037 Kitchen faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
